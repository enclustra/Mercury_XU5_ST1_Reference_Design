do_compile[nostamp] = "1"
do_configure[nostamp] = "1"
